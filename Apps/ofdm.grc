<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>realtime_scheduling</key><value>1</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>dev_addr</key><value>"addr=192.168.40.5"</value></param>
<param><key>sync</key><value></value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>center_freq0</key><value>freq</value></param>
<param><key>gain0</key><value>0</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>1228800</value></param>
</block>
<block>
<key>blks2_rational_resampler_xxx</key>
<param><key>id</key><value>blks2_rational_resampler_xxx_0</value></param>
<param><key>type</key><value>fff</value></param>
<param><key>decim</key><value>wav_fs</value></param>
<param><key>interp</key><value>int(data_rate_bps/resample_rate)</value></param>
<param><key>taps</key><value>[]</value></param>
<param><key>fractional_bw</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>chips_per_bit</value></param>
<param><key>value</key><value>64</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>dev_addr</key><value>"addr=192.168.40.1"</value></param>
<param><key>sync</key><value></value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>center_freq0</key><value>freq</value></param>
<param><key>gain0</key><value>0</value></param>
<param><key>ant0</key><value>RX2</value></param>
</block>
<block>
<key>gr_wavfile_source</key>
<param><key>id</key><value>gr_wavfile_source_0</value></param>
<param><key>file</key><value>/home/crlab/Desktop/11k16bitpcm.wav</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>nchan</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>920e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>wav_fs</value></param>
<param><key>value</key><value>11025</value></param>
</block>
<block>
<key>blks2_ofdm_mod</key>
<param><key>id</key><value>blks2_ofdm_mod_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>modulation</key><value>bpsk</value></param>
<param><key>fft_length</key><value>512</value></param>
<param><key>occupied_tones</key><value>200</value></param>
<param><key>cp_length</key><value>128</value></param>
<param><key>pad_for_usrp</key><value>True</value></param>
<param><key>payload_length</key><value>0</value></param>
</block>
<block>
<key>blks2_cvsd_encode</key>
<param><key>id</key><value>blks2_cvsd_encode_0</value></param>
<param><key>resample</key><value>resample_rate</value></param>
<param><key>bw</key><value>0.5</value></param>
</block>
<block>
<key>blks2_ofdm_demod</key>
<param><key>id</key><value>blks2_ofdm_demod_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>modulation</key><value>bpsk</value></param>
<param><key>fft_length</key><value>512</value></param>
<param><key>occupied_tones</key><value>200</value></param>
<param><key>cp_length</key><value>128</value></param>
<param><key>snr</key><value>10</value></param>
</block>
<block>
<key>blks2_cvsd_decode</key>
<param><key>id</key><value>blks2_cvsd_decode_0</value></param>
<param><key>resample</key><value>resample_rate</value></param>
<param><key>bw</key><value>0.5</value></param>
</block>
<block>
<key>blks2_rational_resampler_xxx</key>
<param><key>id</key><value>blks2_rational_resampler_xxx_1</value></param>
<param><key>type</key><value>fff</value></param>
<param><key>decim</key><value>int(data_rate_bps/resample_rate)</value></param>
<param><key>interp</key><value>wav_fs</value></param>
<param><key>taps</key><value>[]</value></param>
<param><key>fractional_bw</key><value>0</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>samp_rate</key><value>wav_fs</value></param>
<param><key>device_name</key><value>plughw:0,0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>resample_rate</value></param>
<param><key>value</key><value>8</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>data_rate_bps</value></param>
<param><key>value</key><value>96e3</value></param>
</block>
<connection><source_block_id>blks2_cvsd_decode_0</source_block_id><sink_block_id>blks2_rational_resampler_xxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_rational_resampler_xxx_1</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>blks2_ofdm_demod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_ofdm_mod_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_rational_resampler_xxx_0</source_block_id><sink_block_id>blks2_cvsd_encode_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_wavfile_source_0</source_block_id><sink_block_id>blks2_rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_cvsd_encode_0</source_block_id><sink_block_id>blks2_ofdm_mod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_ofdm_demod_0</source_block_id><sink_block_id>blks2_cvsd_decode_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
