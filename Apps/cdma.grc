<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>925e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>wav_fs</value></param>
<param><key>value</key><value>11025</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>1228800</value></param>
</block>
<block>
<key>gr_wavfile_source</key>
<param><key>id</key><value>gr_wavfile_source_0</value></param>
<param><key>file</key><value>/home/crlab/Desktop/11k16bitpcm.wav</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>nchan</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>resample_rate</value></param>
<param><key>value</key><value>8</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>data_rate_bps</value></param>
<param><key>value</key><value>96e3</value></param>
</block>
<block>
<key>blks2_rational_resampler_xxx</key>
<param><key>id</key><value>blks2_rational_resampler_xxx_0</value></param>
<param><key>type</key><value>fff</value></param>
<param><key>decim</key><value>wav_fs</value></param>
<param><key>interp</key><value>int(data_rate_bps/resample_rate)</value></param>
<param><key>taps</key><value>[]</value></param>
<param><key>fractional_bw</key><value>0</value></param>
</block>
<block>
<key>gr_xor_xx</key>
<param><key>id</key><value>gr_xor_xx_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>num_inputs</key><value>2</value></param>
</block>
<block>
<key>blks2_cvsd_encode</key>
<param><key>id</key><value>blks2_cvsd_encode_0</value></param>
<param><key>resample</key><value>resample_rate</value></param>
<param><key>bw</key><value>0.5</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>samp_rate</key><value>wav_fs</value></param>
</block>
<block>
<key>blks2_rational_resampler_xxx</key>
<param><key>id</key><value>blks2_rational_resampler_xxx_1</value></param>
<param><key>type</key><value>fff</value></param>
<param><key>decim</key><value>int(data_rate_bps/resample_rate)</value></param>
<param><key>interp</key><value>wav_fs</value></param>
<param><key>taps</key><value>[]</value></param>
<param><key>fractional_bw</key><value>0</value></param>
</block>
<block>
<key>gr_unpacked_to_packed_xx</key>
<param><key>id</key><value>gr_unpacked_to_packed_xx_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>bits_per_chunk</key><value>1</value></param>
<param><key>endianness</key><value>gr.GR_LSB_FIRST</value></param>
<param><key>num_ports</key><value>1</value></param>
</block>
<block>
<key>blks2_cvsd_decode</key>
<param><key>id</key><value>blks2_cvsd_decode_0</value></param>
<param><key>resample</key><value>resample_rate</value></param>
<param><key>bw</key><value>0.5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>chips_per_bit</value></param>
<param><key>value</key><value>64</value></param>
</block>
<block>
<key>gr_not_xx</key>
<param><key>id</key><value>gr_not_xx_0</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>gr_keep_one_in_n</key>
<param><key>id</key><value>gr_keep_one_in_n_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>n</key><value>chips_per_bit</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_not_xx</key>
<param><key>id</key><value>gr_not_xx_0_0</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>gr_packed_to_unpacked_xx</key>
<param><key>id</key><value>gr_packed_to_unpacked_xx_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>bits_per_chunk</key><value>1</value></param>
<param><key>endianness</key><value>gr.GR_LSB_FIRST</value></param>
<param><key>num_ports</key><value>1</value></param>
</block>
<block>
<key>gr_repeat</key>
<param><key>id</key><value>gr_repeat_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>interp</key><value>chips_per_bit</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>random_source_x</key>
<param><key>id</key><value>random_source_x_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>2</value></param>
<param><key>num_samps</key><value>chips_per_bit</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>gr_xor_xx</key>
<param><key>id</key><value>gr_xor_xx_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>num_inputs</key><value>2</value></param>
</block>
<connection><source_block_id>gr_wavfile_source_0</source_block_id><sink_block_id>blks2_rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_rational_resampler_xxx_0</source_block_id><sink_block_id>blks2_cvsd_encode_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_xor_xx_0</source_block_id><sink_block_id>gr_not_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_repeat_0</source_block_id><sink_block_id>gr_xor_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>random_source_x_0</source_block_id><sink_block_id>gr_xor_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>gr_not_xx_0</source_block_id><sink_block_id>gr_not_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_not_xx_0_0</source_block_id><sink_block_id>gr_xor_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_xor_xx_0_0</source_block_id><sink_block_id>gr_keep_one_in_n_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_cvsd_encode_0</source_block_id><sink_block_id>gr_packed_to_unpacked_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_packed_to_unpacked_xx_0</source_block_id><sink_block_id>gr_repeat_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_rational_resampler_xxx_1</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_cvsd_decode_0</source_block_id><sink_block_id>blks2_rational_resampler_xxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_keep_one_in_n_0</source_block_id><sink_block_id>gr_unpacked_to_packed_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_unpacked_to_packed_xx_0</source_block_id><sink_block_id>blks2_cvsd_decode_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>random_source_x_0</source_block_id><sink_block_id>gr_xor_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
</flow_graph>
